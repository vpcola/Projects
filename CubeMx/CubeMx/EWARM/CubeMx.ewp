# IAR project CubeMx.ewp, settings and files
configuration CubeMx Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/src/include/ipv4; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/LwIP/system/arch; ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/src/netif/ppp; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: CubeMx Configuration.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_cortex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_cortex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_dma.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s startup_stm32f407xx.s
  group Application/User
    ./: 
    ../Src/: spi.c user_diskio.c usart.c tim.c main.c lwip.c stm32f4xx_hal_msp.c sdio.c fatfs.c fsmc.c freertos.c dcmi.c i2c.c gpio.c stm32f4xx_it.c ethernetif.c spi.c user_diskio.c usart.c tim.c main.c lwip.c stm32f4xx_hal_msp.c sdio.c fatfs.c fsmc.c freertos.c dcmi.c i2c.c gpio.c stm32f4xx_it.c ethernetif.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Middlewares
    ./: 
  group Middlewares/FreeRTOS
    ./: 
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s port.c portasm.s
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c timers.c queue.c event_groups.c croutine.c list.c tasks.c timers.c queue.c event_groups.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
  group Middlewares/LwIP
    ./: 
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chap.c fsm.c randm.c ppp.c ppp_oe.c auth.c lcp.c vj.c md5.c chpms.c magic.c pap.c ipcp.c chap.c fsm.c randm.c ppp.c ppp_oe.c auth.c lcp.c vj.c md5.c chpms.c magic.c pap.c ipcp.c
    ../Middlewares/Third_Party/LwIP/src/core/: mem.c memp.c dns.c udp.c tcp_in.c init.c stats.c dhcp.c netif.c lwip_timers.c def.c pbuf.c raw.c sys.c tcp.c tcp_out.c mem.c memp.c dns.c udp.c tcp_in.c init.c stats.c dhcp.c netif.c lwip_timers.c def.c pbuf.c raw.c sys.c tcp.c tcp_out.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: inet.c icmp.c igmp.c ip.c ip_addr.c autoip.c inet_chksum.c ip_frag.c inet.c icmp.c igmp.c ip.c ip_addr.c autoip.c inet_chksum.c ip_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: asn1_dec.c mib_structs.c msg_out.c msg_in.c mib2.c asn1_enc.c asn1_dec.c mib_structs.c msg_out.c msg_in.c mib2.c asn1_enc.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c err.c api_lib.c api_msg.c tcpip.c netifapi.c sockets.c netdb.c netbuf.c err.c api_lib.c api_msg.c tcpip.c netifapi.c sockets.c netdb.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c etharp.c slipif.c
  group Middlewares/FatFs
    ./: 
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c syscall.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
